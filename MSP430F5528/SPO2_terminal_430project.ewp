# IAR project SPO2_terminal_430project.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.PreInclude: types.h
  ICC430.newCCIncludePaths: \MSP430F5528\F5xx_F6xx_Core_Lib; E:\血氧实现\血氧产品终端布局\Source_project\MSP430F5528\AFE44x0_MSP430F5528_APP; E:\血氧实现\血氧产品终端布局\Source_project\MSP430F5528; $PROJ_DIR$; F5xx_F6xx_Core_Lib; AFE44x0_MSP430F5528_APP
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5528.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: AFE44x0_main.c AFE44x0_main.h OLED.c OLED_FRONT.h Power_Mon.c Spo2_Functions.c Spo2_Functions.h
  group AFE44x0_MSP430F5528_APP
    AFE44x0_MSP430F5528_APP/: AFE44x0.c AFE44x0.h
    ./: types.h
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h hal_macros.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
